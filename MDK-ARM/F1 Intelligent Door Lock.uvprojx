# Keil uVision project F1 Intelligent Door Lock.uvprojx, settings and files
target F1 Intelligent Door Lock (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F1 Intelligent Door Lock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../SDK/LED;../SDK/KEY;../SDK/LCD;../SDK/AS608;../SDK/BLUETOOTH;../SDK/Servo;../SYSTEM;../SDK/RC522;../SDK/HRSR04
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group SYSTEM
    ../SYSTEM/: Delay.c Uart_Redefine.c StmFlash.c
  group LED
    ../SDK/LED/: LED.c
  group KEY
    ../SDK/KEY/: Key.c
  group LCD
    ../SDK/LCD/: lcd.c lcd_init.c
  group Fingerprint
    ../SDK/AS608/: AS608.c
  group RFID
    ../SDK/RC522/: RC522.c
  group BlueTooth
    ../SDK/BLUETOOTH/: HC05.c
  group Servo
    ../SDK/Servo/: Servo.c
  group Ultrasonic
    ../SDK/HRSR04/: HCSR04.c
software components: CMSIS:CORE 4.3.0
